
COMPATIBLE_MACHINE:sports-cle-v40 = "sports-cle-v40"

MODEL:sports-cle-v40 = "qihua-s905d3"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2dbd68496cc5ed3e68e855100cb86363"

SRC_URI = "git://github.com/elecboy/amlogic-boot-fip.git;protocol=https;branch=master"
SRCREV = "a9e2f041305ae25bfc6c082a711bd31ccb1cb57e"
