
COMPATIBLE_MACHINE_qihua-s905d3 = "qihua-s905d3"

#SUBDIR_qihua-s905d3 = "odroid-c4"
SUBDIR_qihua-s905d3 = "u200"

DEPLOY_CMD_qihua-s905d3 = "do_deploy_g12a"
