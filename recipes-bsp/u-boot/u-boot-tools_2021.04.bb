require u-boot-common_${PV}.inc
require u-boot-tools.inc

DEPENDS += "bison-native bc-native dtc-native python3-native amlogic-fip"

