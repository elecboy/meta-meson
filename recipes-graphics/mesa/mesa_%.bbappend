PACKAGECONFIG:append_meson-gx = "kmsro lima panfrost"
